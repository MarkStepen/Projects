# Keil uVision project pulsesensor_stm32f103_mdk4.uvproj, settings and files
target pulsesensor_stm32f103_mdk4 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: pulsesensor_stm32f103_mdk4 Configuration +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ..\Inc;         ..\Drivers\STM32F1xx_HAL_Driver\Inc;         ..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;         ..\Drivers\CMSIS\Include;         ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;        ../Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;        ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f1xx_it.c main.c stm32f1xx_hal_msp.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_pwr.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_adc.c stm32f1xx_hal_flash.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_adc.c stm32f1xx_hal_rcc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
